options:
  parameters:
    generate_options: qt_gui
    id: fskDemodulation
    output_language: python
    title: 'FSK Demodulation '
  states: {}

blocks:
- name: cutoff_frequency
  id: variable
  parameters:
    value: '30'
  states: {}
- name: frequency1
  id: variable
  parameters:
    value: '20'
  states: {}
- name: frequency2
  id: variable
  parameters:
    value: '60'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '0'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Channel Noise
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation/8.0)
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/kikas/Desktop/a3sat/spacecraft-communications-workshop-2022/ground-station/io/fskOutput.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '40'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,cutoff_frequency,transition_bw)
    type: fcc
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    fbw: '0.0001'
    interp: '1'
    taps: ''
    type: fff
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Channel
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Channel
  states: {}

connections:
- [blocks_complex_to_real_0, '0', virtual_sink_0, '0']
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', blocks_complex_to_real_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
